options:
  parameters:
    category: Custom
    comment: Single-satellite GPS L1 C/A spread-spectrum continuous transmit mirror flowgraph for B210, QT preview, and lab bring-up.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: gnss_tx_main
    output_language: python
    title: GNSS TX Single-Sat B210
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: nav_pattern
  id: variable
  parameters:
    value: '"1 0 1 1 0 0 1 0"'
  states: {}
- name: prn_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.023e6 * samples_per_chip
  states: {}
- name: samp_rate_label
  id: variable_qtgui_label
  parameters:
    comment: 配置采样率标签：显示 GRC 变量 samp_rate（请求值）。 实际 UHD 硬件确认采样率（经整数分频舍入后） 通过 sink.get_samp_rate() 读回，在 run_tx.py 终端打印。
    gui_hint: 1,0,1,2
    label: TX 采样率（配置值）Msps
    type: real
    value: samp_rate / 1e6
  states: {}
- name: samples_per_chip
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"type=b200"'
  states: {}
- name: amplitude_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: prn_source
  id: gnss_tx_gps_l1_ca_source
  parameters:
    amplitude: '1.0'
    initial_code_phase: '0'
    initial_nav_bit_index: '0'
    initial_nav_epoch: '0'
    nav_pattern: nav_pattern
    prn_id: prn_id
    samples_per_chip: samples_per_chip
  states: {}
- name: qt_freq
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: '"Selected PRN RF Preview"'
    name: '"Selected PRN Baseband Spectrum"'
    type: complex
    ymin: '-120'
  states: {}
- name: qt_time
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: I
    label2: Q
    name: '"Selected PRN Baseband Time"'
    size: '512'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: safety_note
  id: note
  parameters:
    note: |-
      This flowgraph is a GNU Radio Companion mirror of the Python runtime transmit chain.
      It supports single-satellite mode: select any GPS L1 C/A PRN (1~32) via the prn_id variable.
      The custom source replays a precomputed spread-spectrum buffer continuously to reduce USRP underflows.
      Signal type: single-satellite GPS L1 C/A spread-spectrum BPSK complex baseband.
      For multi-PRN combined transmission (all 32 PRNs superimposed), use run_tx.py with configs/tx_b210_all32prn.yaml.
      Internal source amplitude stays at 1.0; RF strength is adjusted here with tx_gain and the output multiply_const block.
      Check QT GUI time/frequency views before connecting the spectrum analyzer.
      Analyzer max input: 30 dBm, 50 V DC, 50 ohm. Start with low tx_gain.
  states: {}
- name: usrp_sink
  id: gnss_tx_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: usrp_addr
    gain0: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [amplitude_scale, '0', qt_freq, '0']
- [amplitude_scale, '0', qt_time, '0']
- [amplitude_scale, '0', usrp_sink, '0']
- [prn_source, '0', amplitude_scale, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
